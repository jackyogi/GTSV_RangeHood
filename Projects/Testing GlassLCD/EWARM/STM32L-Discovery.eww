<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Working GTSV\EWARM\GTSV-BlackControl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\STM32L-Discovery.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\TestTouch\EWARM\testTouch.ewp</path>
  </project>
  <batchBuild/>
</workspace>



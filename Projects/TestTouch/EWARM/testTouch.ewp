# IAR project testTouch.ewp, settings and files
configuration STM32L-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152x8 ST STM32L152x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\libraries\STM32_TouchSensing_Driver\inc; ..\..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\libraries\STMTouch_Driver\inc; ..\..\..\Utilities\STM32L-DISCOVERY
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testTouch.hex
  ILINK.IlinkOutputFile: STM32L-Discovery.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group STM32L-Discovery
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c
  group TouchSensingDriver
    ../../../Libraries/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32l1xx_sw.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32l1xx.c tsl_touchkey.c
  group User
    ../src/: main.c stm32l1xx_it.c system_stm32l1xx.c tsl_user.c
    ../inc/: tsl_user.h
